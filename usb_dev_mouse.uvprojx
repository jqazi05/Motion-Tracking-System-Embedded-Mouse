# Keil uVision project usb_dev_mouse.uvprojx, settings and files
target usb_dev_mouse (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_dev_mouse
  c flags: Optim=3 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1 UART_BUFFERED
  c include: "C:\ti\TivaWare_C_Series-2.2.0.295"
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_dev_mouse.sct
  link misc: --entry Reset_Handler --diag_suppress L6366
  group Source
    ./: uartstdio.c usb_mouse_structs.c usb_dev_mouse.c usb_mouse_structs.h startup_rvmdk.S buttons.c
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/ccs/Debug/: driverlib.lib
    ../TivaWare_C_Series-2.2.0.295/usblib/ccs/Debug/: usblib.lib
